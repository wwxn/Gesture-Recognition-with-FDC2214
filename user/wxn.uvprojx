# Keil uVision project wxn.uvprojx, settings and files
target wxn (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: wxn +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\user;..\core;..\lib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\hardware\key;..\hardware\LCD;..\USMART;..\hardware\FDC2214;..\hardware\IIC;..\hardware\pwm;..\hardware\led;..\hardware\USART3;..\hardware\kalman;..\hardware\datascope;..\hardware\motor
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group core
    ../core/: core_cm3.c startup_stm32f10x_hd.s
  group lib
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group system
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group hardware
    ../hardware/LCD/: lcd.c
    ../hardware/key/: key.c
    ../hardware/led/: led.c
    ../hardware/kalman/: kalman.c
    ../hardware/datascope/: DataScope_DP.C
    ../hardware/FDC2214/: fdc2214.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
